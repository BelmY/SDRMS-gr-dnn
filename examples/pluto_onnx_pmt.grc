options:
  parameters:
    author: Kevin JOLY
    category: Custom
    description: Test for ONNX inference
    generate_options: qt_gui
    id: classifier_test
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: batch_size
  id: variable
  parameters:
    value: '10'
  states: {}
- name: input_len
  id: variable
  parameters:
    value: 256*batch_size
  states: {}
- name: output_len
  id: variable
  parameters:
    value: 1*batch_size
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: output_len
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: input_len
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: dnn_dnn_onnx_python_0
  id: dnn_dnn_onnx_python
  parameters:
    enableProfiling: 'False'
    onnxModelFilePath: ''
    profilingPrintInterval: '1.0'
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2480000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '4000000'
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '16'
    nrows: '512'
    samp_rate: '1'
    type: float
    zmin: '0'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, dnn_dnn_onnx_python_0, Input]
- [dnn_dnn_onnx_python_0, Output, blocks_pdu_to_tagged_stream_0, pdus]
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
