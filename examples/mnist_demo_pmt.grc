options:
  parameters:
    author: Kevin JOLY
    category: Custom
    description: Test for ONNX inference
    generate_options: qt_gui
    id: classifier_test
    output_language: python
    run_options: run
    title: Classifier Test
  states: {}

blocks:
- name: input_len
  id: variable
  parameters:
    value: '784'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '10'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/255.0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: output_len
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: input_len
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '10'
    type: float
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '1000000'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dnn_dnn_onnx_python_0
  id: dnn_dnn_onnx_python
  parameters:
    enableProfiling: 'False'
    onnxModelFilePath: /root/models/mnist/model.onnx
    profilingPrintInterval: '1.0'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Number found
    max: '1000'
    min: '-1000'
    name: '"Classifier"'
    type: short
    update_time: '-1'
  states: {}
- name: source
  id: blocks_file_source
  parameters:
    file: /root/models/mnist/1.bin
    repeat: 'True'
    type: byte
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '0'
    height: '28'
    type: byte
    width: '28'
  states: {}

connections:
- [blocks_argmax_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_argmax_xx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, dnn_dnn_onnx_python_0, Input]
- [blocks_throttle_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle_0, '0', video_sdl_sink_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_xx_0, '0']
- [dnn_dnn_onnx_python_0, Output, blocks_pdu_to_tagged_stream_0, pdus]
- [source, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
