options:
  parameters:
    generate_options: qt_gui
    id: Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '10'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /root/models/mnist/2.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1.0/255.0
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 28*28
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: dnn_dnn_onnx_sync_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: 28*28
    onnx_batch_size: '1'
    onnx_model_file: /root/models/mnist/model.onnx
    onnx_runtime_device: GPU
    output_size: '10'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: Classifier
    type: short
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    display_height: '480'
    display_width: '640'
    fps: '0'
    height: '28'
    type: byte
    width: '28'
  states: {}

connections:
- [blocks_argmax_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_file_source_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_file_source_0, '0', video_sdl_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', dnn_dnn_onnx_sync_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_xx_0, '0']
- [dnn_dnn_onnx_sync_0, '0', blocks_argmax_xx_0, '0']

metadata:
  file_format: 1
