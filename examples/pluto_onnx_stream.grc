options:
  parameters:
    author: Oscar Rodriguez
    category: Custom
    description: Test for ONNX inference using streams
    generate_options: qt_gui
    id: onnx_stream_test
    output_language: python
    run_options: run
    title: Onnx Stream
  states: {}

blocks:
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '1'
    type: float
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: dnn_dnn_onnx_stream_0
  id: dnn_dnn_onnx_stream
  parameters:
    onnx_batch_size: '10'
    onnx_model_file: /root/models/RES_SIGNN_20190828071811.onnx
    onnx_runtime_device: GPU
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2480000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '4000000'
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: '11'
    nrows: '1024'
    samp_rate: '16000'
    type: float
    update_time: '0.01'
    zmin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '20000000'
    fc: '2480000000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', dnn_dnn_onnx_stream_0, '0']
- [dnn_dnn_onnx_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
