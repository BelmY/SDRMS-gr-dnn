options:
  parameters:
    author: Oscar Rodriguez
    category: Custom
    description: Test for ONNX inference using streams
    generate_options: qt_gui
    id: onnx_sync_test
    output_language: python
    run_options: run
    title: Onnx Stream
  states: {}

blocks:
- name: input_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: output_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    num_streams: '1'
    type: float
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2*input_len
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: output_len
    type: float
  states: {}
- name: dnn_dnn_onnx_sync_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: 2*input_len
    onnx_batch_size: '200'
    onnx_model_file: /root/models/VGG_RML2016.10b_20190426084923.onnx
    onnx_runtime_device: GPU
    output_size: output_len
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2400000000'
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: '4000000'
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_time_raster_sink_x_1
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: output_len
    nrows: '1024'
    samp_rate: '300000'
    type: float
    update_time: '0.001'
    zmin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '20000000'
    fc: '2480000000'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [blocks_complex_to_float_0, '0', blocks_interleave_0, '0']
- [blocks_complex_to_float_0, '1', blocks_interleave_0, '1']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', dnn_dnn_onnx_sync_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_1, '0']
- [dnn_dnn_onnx_sync_0, '0', blocks_vector_to_stream_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
